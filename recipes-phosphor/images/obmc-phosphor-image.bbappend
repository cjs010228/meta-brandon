OBMC_IMAGE_EXTRA_INSTALL:append = " entity-manager my-heartbeat"
