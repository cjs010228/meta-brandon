# Enable dynamic sensors (dbus-sdr)
PACKAGECONFIG:append = " dynamic-sensors"
